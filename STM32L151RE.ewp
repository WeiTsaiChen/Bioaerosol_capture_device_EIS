# IAR project STM32L151RE.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xE ST STM32L151xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L1XX_XL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: STM32\CMSIS\Include; STM32\CMSIS\Device\ST\STM32L1xx\Include; STM32\STM32L1xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L151RE.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: STM32\STM32L151RE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: main.c main.h
  group AD5941
    AD5941/drv_src/: ad5941_drv.c ad5941_drv.h
    AD5941/c_src/: ad5941_glb_vars.c ad5941_glb_vars.h ad5941_idef.h ad5941_impedance.c ad5941_impedance.h ad5941_init.c ad5941_init.h ad5941_ramp.c ad5941_ramp.h ad5941_task.c ad5941_task.h
    AD5941/: ad5941_udef.h
  group BLE
    BLE/drv_src/: ble_drv.c ble_drv.h
    BLE/c_src/: ble_glb_vars.c ble_glb_vars.h ble_idef.h ble_init.c ble_init.h ble_task.c ble_task.h
    BLE/: ble_udef.h
  group BTC
    BTC/drv_src/: btc_drv.c btc_drv.h
    BTC/c_src/: btc_glb_vars.c btc_glb_vars.h btc_idef.h btc_init.c btc_init.h btc_task.c btc_task.h
    BTC/: btc_udef.h
  group CMSIS
    STM32/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_xl.s
    STM32/CMSIS/Device/ST/STM32L1xx/Include/: stm32l1xx.h system_stm32l1xx.h
    STM32/STM32L1xx_StdPeriph_Driver/inc/: stm32l1xx_conf.h
    STM32/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group CMSIS/CRC
    CRC/drv_src/: crc_drv.c crc_drv.h
    CRC/c_src/: crc_glb_vars.c crc_glb_vars.h crc_idef.h crc_init.c crc_init.h crc_task.c crc_task.h
    CRC/: crc_udef.h
  group FK
    FK/: fk_adc_udef.h fk_dac_udef.h fk_dma_udef.h fk_flash_udef.h fk_gpio_udef.h fk_i2c_udef.h fk_nvic_udef.h fk_power_udef.h fk_rtc_udef.h fk_spi_udef.h fk_system_udef.h fk_timer_udef.h fk_uart_udef.h fk_udef.h fk_watch_dog_udef.h
    FK/drv_src/: fk_drv.c fk_drv.h
    FK/c_src/: fk_glb_vars.c fk_glb_vars.h fk_idef.h fk_init.c fk_init.h fk_task.c fk_task.h
  group HBTC
    HBTC/drv_src/: hbtc_drv.c hbtc_drv.h
    HBTC/c_src/: hbtc_glb_vars.c hbtc_glb_vars.h hbtc_idef.h hbtc_init.c hbtc_init.h hbtc_task.c hbtc_task.h
    HBTC/: hbtc_udef.h
  group MODBUS_SLAVE
    MODBUS_SLAVE/drv_src/: modbus_slave_drv.c modbus_slave_drv.h
    MODBUS_SLAVE/c_src/: modbus_slave_glb_vars.c modbus_slave_glb_vars.h modbus_slave_idef.h modbus_slave_init.c modbus_slave_init.h modbus_slave_task.c modbus_slave_task.h
    MODBUS_SLAVE/: modbus_slave_udef.h
  group PFC
    PFC/drv_src/: pfc_drv.c pfc_drv.h
    PFC/c_src/: pfc_glb_vars.c pfc_glb_vars.h pfc_idef.h pfc_init.c pfc_init.h pfc_task.c pfc_task.h
    PFC/: pfc_udef.c pfc_udef.h
  group STM32
    STM32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
    STM32/STM32L1xx_StdPeriph_Driver/inc/: misc.h stm32l1xx_adc.h stm32l1xx_aes.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_fsmc.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_opamp.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_sdio.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
