<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>AD5941</name>
    <file>
      <name>$PROJ_DIR$\AD5941\drv_src\ad5941_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\drv_src\ad5941_drv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_glb_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_glb_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_idef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_impedance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_impedance.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_ramp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_ramp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\c_src\ad5941_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\AD5941\ad5941_udef.h</name>
    </file>
  </group>
  <group>
    <name>BLE</name>
    <file>
      <name>$PROJ_DIR$\BLE\drv_src\ble_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\drv_src\ble_drv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\c_src\ble_glb_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\c_src\ble_glb_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\c_src\ble_idef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\c_src\ble_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\c_src\ble_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\c_src\ble_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\c_src\ble_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BLE\ble_udef.h</name>
    </file>
  </group>
  <group>
    <name>BTC</name>
    <file>
      <name>$PROJ_DIR$\BTC\drv_src\btc_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\drv_src\btc_drv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\c_src\btc_glb_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\c_src\btc_glb_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\c_src\btc_idef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\c_src\btc_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\c_src\btc_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\c_src\btc_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\c_src\btc_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\BTC\btc_udef.h</name>
    </file>
  </group>
  <group>
    <name>CMSIS</name>
    <group>
      <name>CRC</name>
      <file>
        <name>$PROJ_DIR$\CRC\drv_src\crc_drv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\drv_src\crc_drv.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\c_src\crc_glb_vars.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\c_src\crc_glb_vars.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\c_src\crc_idef.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\c_src\crc_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\c_src\crc_init.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\c_src\crc_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\c_src\crc_task.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\CRC\crc_udef.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\STM32\CMSIS\Device\ST\STM32L1xx\Source\Templates\iar\startup_stm32l1xx_xl.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\CMSIS\Device\ST\STM32L1xx\Include\stm32l1xx.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\CMSIS\Device\ST\STM32L1xx\Source\Templates\system_stm32l1xx.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\CMSIS\Device\ST\STM32L1xx\Include\system_stm32l1xx.h</name>
    </file>
  </group>
  <group>
    <name>FK</name>
    <file>
      <name>$PROJ_DIR$\FK\fk_adc_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_dac_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_dma_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\drv_src\fk_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\drv_src\fk_drv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_flash_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\c_src\fk_glb_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\c_src\fk_glb_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_gpio_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_i2c_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\c_src\fk_idef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\c_src\fk_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\c_src\fk_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_nvic_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_power_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_rtc_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_spi_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_system_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\c_src\fk_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\c_src\fk_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_timer_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_uart_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_udef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FK\fk_watch_dog_udef.h</name>
    </file>
  </group>
  <group>
    <name>HBTC</name>
    <file>
      <name>$PROJ_DIR$\HBTC\drv_src\hbtc_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\drv_src\hbtc_drv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\c_src\hbtc_glb_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\c_src\hbtc_glb_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\c_src\hbtc_idef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\c_src\hbtc_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\c_src\hbtc_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\c_src\hbtc_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\c_src\hbtc_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\HBTC\hbtc_udef.h</name>
    </file>
  </group>
  <group>
    <name>MODBUS_SLAVE</name>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\drv_src\modbus_slave_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\drv_src\modbus_slave_drv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\c_src\modbus_slave_glb_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\c_src\modbus_slave_glb_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\c_src\modbus_slave_idef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\c_src\modbus_slave_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\c_src\modbus_slave_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\c_src\modbus_slave_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\c_src\modbus_slave_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\MODBUS_SLAVE\modbus_slave_udef.h</name>
    </file>
  </group>
  <group>
    <name>PFC</name>
    <file>
      <name>$PROJ_DIR$\PFC\drv_src\pfc_drv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\drv_src\pfc_drv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\c_src\pfc_glb_vars.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\c_src\pfc_glb_vars.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\c_src\pfc_idef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\c_src\pfc_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\c_src\pfc_init.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\c_src\pfc_task.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\c_src\pfc_task.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\pfc_udef.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\PFC\pfc_udef.h</name>
    </file>
  </group>
  <group>
    <name>STM32</name>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\misc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_adc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_aes.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_aes_util.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_comp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_comp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_crc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_dac.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_dbgmcu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_dma.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_flash_ramfunc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_fsmc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_i2c.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_iwdg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_lcd.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_lcd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_opamp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_opamp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_pwr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_rcc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_rtc.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_sdio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_syscfg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_tim.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_usart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\src\stm32l1xx_wwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM32\STM32L1xx_StdPeriph_Driver\inc\stm32l1xx_wwdg.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.h</name>
  </file>
</project>


